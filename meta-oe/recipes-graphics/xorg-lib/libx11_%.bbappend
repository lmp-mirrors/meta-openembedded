SYSROOT_DIRS_IGNORE:remove:class-native = "${datadir}/X11/locale"
